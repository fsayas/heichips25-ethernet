VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO line_driver
  CLASS BLOCK ;
  FOREIGN line_driver ;
  ORIGIN 0.000 0.000 ;
  SIZE 320.160 BY 195.060 ;
  OBS
      LAYER GatPoly ;
        RECT 31.200 186.550 35.700 191.550 ;
        RECT 45.700 186.550 46.610 191.550 ;
        RECT 56.610 186.550 57.610 191.550 ;
        RECT 95.200 186.550 95.700 191.550 ;
        RECT 105.700 186.550 106.610 191.550 ;
        RECT 116.610 186.550 117.520 191.550 ;
        RECT 127.520 186.550 128.430 191.550 ;
        RECT 138.430 186.550 141.430 191.550 ;
        RECT 183.200 186.550 185.700 191.550 ;
        RECT 195.700 186.550 196.610 191.550 ;
        RECT 206.610 186.550 207.520 191.550 ;
        RECT 217.520 186.550 218.430 191.550 ;
        RECT 228.430 186.550 229.340 191.550 ;
        RECT 239.340 186.550 240.250 191.550 ;
        RECT 250.250 186.550 251.160 191.550 ;
        RECT 261.160 186.550 262.070 191.550 ;
        RECT 272.070 186.550 272.980 191.550 ;
        RECT 282.980 186.550 283.890 191.550 ;
        RECT 293.890 186.550 294.800 191.550 ;
        RECT 304.800 186.550 305.800 191.550 ;
        RECT 31.200 181.170 35.700 186.170 ;
        RECT 45.700 181.170 46.610 186.170 ;
        RECT 56.610 181.170 57.610 186.170 ;
        RECT 95.200 181.170 95.700 186.170 ;
        RECT 105.700 181.170 106.610 186.170 ;
        RECT 116.610 181.170 117.520 186.170 ;
        RECT 127.520 181.170 128.430 186.170 ;
        RECT 138.430 181.170 141.430 186.170 ;
        RECT 183.200 181.170 185.700 186.170 ;
        RECT 195.700 181.170 196.610 186.170 ;
        RECT 206.610 181.170 207.520 186.170 ;
        RECT 217.520 181.170 218.430 186.170 ;
        RECT 228.430 181.170 229.340 186.170 ;
        RECT 239.340 181.170 240.250 186.170 ;
        RECT 250.250 181.170 251.160 186.170 ;
        RECT 261.160 181.170 262.070 186.170 ;
        RECT 272.070 181.170 272.980 186.170 ;
        RECT 282.980 181.170 283.890 186.170 ;
        RECT 293.890 181.170 294.800 186.170 ;
        RECT 304.800 181.170 305.800 186.170 ;
        RECT 31.200 175.790 35.700 180.790 ;
        RECT 45.700 175.790 46.610 180.790 ;
        RECT 56.610 175.790 57.610 180.790 ;
        RECT 95.200 175.790 95.700 180.790 ;
        RECT 105.700 175.790 106.610 180.790 ;
        RECT 116.610 175.790 117.520 180.790 ;
        RECT 127.520 175.790 128.430 180.790 ;
        RECT 138.430 175.790 141.430 180.790 ;
        RECT 183.200 175.790 185.700 180.790 ;
        RECT 195.700 175.790 196.610 180.790 ;
        RECT 206.610 175.790 207.520 180.790 ;
        RECT 217.520 175.790 218.430 180.790 ;
        RECT 228.430 175.790 229.340 180.790 ;
        RECT 239.340 175.790 240.250 180.790 ;
        RECT 250.250 175.790 251.160 180.790 ;
        RECT 261.160 175.790 262.070 180.790 ;
        RECT 272.070 175.790 272.980 180.790 ;
        RECT 282.980 175.790 283.890 180.790 ;
        RECT 293.890 175.790 294.800 180.790 ;
        RECT 304.800 175.790 305.800 180.790 ;
        RECT 31.200 170.410 35.700 175.410 ;
        RECT 45.700 170.410 46.610 175.410 ;
        RECT 56.610 170.410 57.610 175.410 ;
        RECT 95.200 170.410 95.700 175.410 ;
        RECT 105.700 170.410 106.610 175.410 ;
        RECT 116.610 170.410 117.520 175.410 ;
        RECT 127.520 170.410 128.430 175.410 ;
        RECT 138.430 170.410 141.430 175.410 ;
        RECT 183.200 170.410 185.700 175.410 ;
        RECT 195.700 170.410 196.610 175.410 ;
        RECT 206.610 170.410 207.520 175.410 ;
        RECT 217.520 170.410 218.430 175.410 ;
        RECT 228.430 170.410 229.340 175.410 ;
        RECT 239.340 170.410 240.250 175.410 ;
        RECT 250.250 170.410 251.160 175.410 ;
        RECT 261.160 170.410 262.070 175.410 ;
        RECT 272.070 170.410 272.980 175.410 ;
        RECT 282.980 170.410 283.890 175.410 ;
        RECT 293.890 170.410 294.800 175.410 ;
        RECT 304.800 170.410 305.800 175.410 ;
        RECT 31.200 162.750 35.700 167.750 ;
        RECT 45.700 162.750 46.610 167.750 ;
        RECT 56.610 162.750 57.610 167.750 ;
        RECT 95.200 162.750 95.700 167.750 ;
        RECT 105.700 162.750 106.610 167.750 ;
        RECT 116.610 162.750 117.520 167.750 ;
        RECT 127.520 162.750 128.430 167.750 ;
        RECT 138.430 162.750 141.430 167.750 ;
        RECT 183.200 162.750 185.700 167.750 ;
        RECT 195.700 162.750 196.610 167.750 ;
        RECT 206.610 162.750 207.520 167.750 ;
        RECT 217.520 162.750 218.430 167.750 ;
        RECT 228.430 162.750 229.340 167.750 ;
        RECT 239.340 162.750 240.250 167.750 ;
        RECT 250.250 162.750 251.160 167.750 ;
        RECT 261.160 162.750 262.070 167.750 ;
        RECT 272.070 162.750 272.980 167.750 ;
        RECT 282.980 162.750 283.890 167.750 ;
        RECT 293.890 162.750 294.800 167.750 ;
        RECT 304.800 162.750 305.800 167.750 ;
        RECT 31.200 157.370 35.700 162.370 ;
        RECT 45.700 157.370 46.610 162.370 ;
        RECT 56.610 157.370 57.610 162.370 ;
        RECT 95.200 157.370 95.700 162.370 ;
        RECT 105.700 157.370 106.610 162.370 ;
        RECT 116.610 157.370 117.520 162.370 ;
        RECT 127.520 157.370 128.430 162.370 ;
        RECT 138.430 157.370 141.430 162.370 ;
        RECT 183.200 157.370 185.700 162.370 ;
        RECT 195.700 157.370 196.610 162.370 ;
        RECT 206.610 157.370 207.520 162.370 ;
        RECT 217.520 157.370 218.430 162.370 ;
        RECT 228.430 157.370 229.340 162.370 ;
        RECT 239.340 157.370 240.250 162.370 ;
        RECT 250.250 157.370 251.160 162.370 ;
        RECT 261.160 157.370 262.070 162.370 ;
        RECT 272.070 157.370 272.980 162.370 ;
        RECT 282.980 157.370 283.890 162.370 ;
        RECT 293.890 157.370 294.800 162.370 ;
        RECT 304.800 157.370 305.800 162.370 ;
        RECT 31.200 151.990 35.700 156.990 ;
        RECT 45.700 151.990 46.610 156.990 ;
        RECT 56.610 151.990 57.610 156.990 ;
        RECT 95.200 151.990 95.700 156.990 ;
        RECT 105.700 151.990 106.610 156.990 ;
        RECT 116.610 151.990 117.520 156.990 ;
        RECT 127.520 151.990 128.430 156.990 ;
        RECT 138.430 151.990 141.430 156.990 ;
        RECT 183.200 151.990 185.700 156.990 ;
        RECT 195.700 151.990 196.610 156.990 ;
        RECT 206.610 151.990 207.520 156.990 ;
        RECT 217.520 151.990 218.430 156.990 ;
        RECT 228.430 151.990 229.340 156.990 ;
        RECT 239.340 151.990 240.250 156.990 ;
        RECT 250.250 151.990 251.160 156.990 ;
        RECT 261.160 151.990 262.070 156.990 ;
        RECT 272.070 151.990 272.980 156.990 ;
        RECT 282.980 151.990 283.890 156.990 ;
        RECT 293.890 151.990 294.800 156.990 ;
        RECT 304.800 151.990 305.800 156.990 ;
        RECT 31.200 146.610 35.700 151.610 ;
        RECT 45.700 146.610 46.610 151.610 ;
        RECT 56.610 146.610 57.610 151.610 ;
        RECT 95.200 146.610 95.700 151.610 ;
        RECT 105.700 146.610 106.610 151.610 ;
        RECT 116.610 146.610 117.520 151.610 ;
        RECT 127.520 146.610 128.430 151.610 ;
        RECT 138.430 146.610 141.430 151.610 ;
        RECT 183.200 146.610 185.700 151.610 ;
        RECT 195.700 146.610 196.610 151.610 ;
        RECT 206.610 146.610 207.520 151.610 ;
        RECT 217.520 146.610 218.430 151.610 ;
        RECT 228.430 146.610 229.340 151.610 ;
        RECT 239.340 146.610 240.250 151.610 ;
        RECT 250.250 146.610 251.160 151.610 ;
        RECT 261.160 146.610 262.070 151.610 ;
        RECT 272.070 146.610 272.980 151.610 ;
        RECT 282.980 146.610 283.890 151.610 ;
        RECT 293.890 146.610 294.800 151.610 ;
        RECT 304.800 146.610 305.800 151.610 ;
        RECT 31.200 138.950 35.700 143.950 ;
        RECT 45.700 138.950 46.610 143.950 ;
        RECT 56.610 138.950 57.610 143.950 ;
        RECT 95.200 138.950 95.700 143.950 ;
        RECT 105.700 138.950 106.610 143.950 ;
        RECT 116.610 138.950 117.520 143.950 ;
        RECT 127.520 138.950 128.430 143.950 ;
        RECT 138.430 138.950 141.430 143.950 ;
        RECT 183.200 138.950 185.700 143.950 ;
        RECT 195.700 138.950 196.610 143.950 ;
        RECT 206.610 138.950 207.520 143.950 ;
        RECT 217.520 138.950 218.430 143.950 ;
        RECT 228.430 138.950 229.340 143.950 ;
        RECT 239.340 138.950 240.250 143.950 ;
        RECT 250.250 138.950 251.160 143.950 ;
        RECT 261.160 138.950 262.070 143.950 ;
        RECT 272.070 138.950 272.980 143.950 ;
        RECT 282.980 138.950 283.890 143.950 ;
        RECT 293.890 138.950 294.800 143.950 ;
        RECT 304.800 138.950 305.800 143.950 ;
        RECT 8.200 133.680 13.200 134.110 ;
        RECT 31.200 133.570 35.700 138.570 ;
        RECT 45.700 133.570 46.610 138.570 ;
        RECT 56.610 133.570 57.610 138.570 ;
        RECT 95.200 133.570 95.700 138.570 ;
        RECT 105.700 133.570 106.610 138.570 ;
        RECT 116.610 133.570 117.520 138.570 ;
        RECT 127.520 133.570 128.430 138.570 ;
        RECT 138.430 133.570 141.430 138.570 ;
        RECT 183.200 133.570 185.700 138.570 ;
        RECT 195.700 133.570 196.610 138.570 ;
        RECT 206.610 133.570 207.520 138.570 ;
        RECT 217.520 133.570 218.430 138.570 ;
        RECT 228.430 133.570 229.340 138.570 ;
        RECT 239.340 133.570 240.250 138.570 ;
        RECT 250.250 133.570 251.160 138.570 ;
        RECT 261.160 133.570 262.070 138.570 ;
        RECT 272.070 133.570 272.980 138.570 ;
        RECT 282.980 133.570 283.890 138.570 ;
        RECT 293.890 133.570 294.800 138.570 ;
        RECT 304.800 133.570 305.800 138.570 ;
        RECT 31.200 128.190 35.700 133.190 ;
        RECT 45.700 128.190 46.610 133.190 ;
        RECT 56.610 128.190 57.610 133.190 ;
        RECT 95.200 128.190 95.700 133.190 ;
        RECT 105.700 128.190 106.610 133.190 ;
        RECT 116.610 128.190 117.520 133.190 ;
        RECT 127.520 128.190 128.430 133.190 ;
        RECT 138.430 128.190 141.430 133.190 ;
        RECT 183.200 128.190 185.700 133.190 ;
        RECT 195.700 128.190 196.610 133.190 ;
        RECT 206.610 128.190 207.520 133.190 ;
        RECT 217.520 128.190 218.430 133.190 ;
        RECT 228.430 128.190 229.340 133.190 ;
        RECT 239.340 128.190 240.250 133.190 ;
        RECT 250.250 128.190 251.160 133.190 ;
        RECT 261.160 128.190 262.070 133.190 ;
        RECT 272.070 128.190 272.980 133.190 ;
        RECT 282.980 128.190 283.890 133.190 ;
        RECT 293.890 128.190 294.800 133.190 ;
        RECT 304.800 128.190 305.800 133.190 ;
        RECT 31.200 122.810 35.700 127.810 ;
        RECT 45.700 122.810 46.610 127.810 ;
        RECT 56.610 122.810 57.610 127.810 ;
        RECT 95.200 122.810 95.700 127.810 ;
        RECT 105.700 122.810 106.610 127.810 ;
        RECT 116.610 122.810 117.520 127.810 ;
        RECT 127.520 122.810 128.430 127.810 ;
        RECT 138.430 122.810 141.430 127.810 ;
        RECT 183.200 122.810 185.700 127.810 ;
        RECT 195.700 122.810 196.610 127.810 ;
        RECT 206.610 122.810 207.520 127.810 ;
        RECT 217.520 122.810 218.430 127.810 ;
        RECT 228.430 122.810 229.340 127.810 ;
        RECT 239.340 122.810 240.250 127.810 ;
        RECT 250.250 122.810 251.160 127.810 ;
        RECT 261.160 122.810 262.070 127.810 ;
        RECT 272.070 122.810 272.980 127.810 ;
        RECT 282.980 122.810 283.890 127.810 ;
        RECT 293.890 122.810 294.800 127.810 ;
        RECT 304.800 122.810 305.800 127.810 ;
        RECT 31.200 115.150 35.700 120.150 ;
        RECT 45.700 115.150 46.610 120.150 ;
        RECT 56.610 115.150 57.610 120.150 ;
        RECT 95.200 115.150 95.700 120.150 ;
        RECT 105.700 115.150 106.610 120.150 ;
        RECT 116.610 115.150 117.520 120.150 ;
        RECT 127.520 115.150 128.430 120.150 ;
        RECT 138.430 115.150 141.430 120.150 ;
        RECT 183.200 115.150 185.700 120.150 ;
        RECT 195.700 115.150 196.610 120.150 ;
        RECT 206.610 115.150 207.520 120.150 ;
        RECT 217.520 115.150 218.430 120.150 ;
        RECT 228.430 115.150 229.340 120.150 ;
        RECT 239.340 115.150 240.250 120.150 ;
        RECT 250.250 115.150 251.160 120.150 ;
        RECT 261.160 115.150 262.070 120.150 ;
        RECT 272.070 115.150 272.980 120.150 ;
        RECT 282.980 115.150 283.890 120.150 ;
        RECT 293.890 115.150 294.800 120.150 ;
        RECT 304.800 115.150 305.800 120.150 ;
        RECT 31.200 109.770 35.700 114.770 ;
        RECT 45.700 109.770 46.610 114.770 ;
        RECT 56.610 109.770 57.610 114.770 ;
        RECT 95.200 109.770 95.700 114.770 ;
        RECT 105.700 109.770 106.610 114.770 ;
        RECT 116.610 109.770 117.520 114.770 ;
        RECT 127.520 109.770 128.430 114.770 ;
        RECT 138.430 109.770 141.430 114.770 ;
        RECT 183.200 109.770 185.700 114.770 ;
        RECT 195.700 109.770 196.610 114.770 ;
        RECT 206.610 109.770 207.520 114.770 ;
        RECT 217.520 109.770 218.430 114.770 ;
        RECT 228.430 109.770 229.340 114.770 ;
        RECT 239.340 109.770 240.250 114.770 ;
        RECT 250.250 109.770 251.160 114.770 ;
        RECT 261.160 109.770 262.070 114.770 ;
        RECT 272.070 109.770 272.980 114.770 ;
        RECT 282.980 109.770 283.890 114.770 ;
        RECT 293.890 109.770 294.800 114.770 ;
        RECT 304.800 109.770 305.800 114.770 ;
        RECT 31.200 104.390 35.700 109.390 ;
        RECT 45.700 104.390 46.610 109.390 ;
        RECT 56.610 104.390 57.610 109.390 ;
        RECT 95.200 104.390 95.700 109.390 ;
        RECT 105.700 104.390 106.610 109.390 ;
        RECT 116.610 104.390 117.520 109.390 ;
        RECT 127.520 104.390 128.430 109.390 ;
        RECT 138.430 104.390 141.430 109.390 ;
        RECT 183.200 104.390 185.700 109.390 ;
        RECT 195.700 104.390 196.610 109.390 ;
        RECT 206.610 104.390 207.520 109.390 ;
        RECT 217.520 104.390 218.430 109.390 ;
        RECT 228.430 104.390 229.340 109.390 ;
        RECT 239.340 104.390 240.250 109.390 ;
        RECT 250.250 104.390 251.160 109.390 ;
        RECT 261.160 104.390 262.070 109.390 ;
        RECT 272.070 104.390 272.980 109.390 ;
        RECT 282.980 104.390 283.890 109.390 ;
        RECT 293.890 104.390 294.800 109.390 ;
        RECT 304.800 104.390 305.800 109.390 ;
        RECT 31.200 99.010 35.700 104.010 ;
        RECT 45.700 99.010 46.610 104.010 ;
        RECT 56.610 99.010 57.610 104.010 ;
        RECT 95.200 99.010 95.700 104.010 ;
        RECT 105.700 99.010 106.610 104.010 ;
        RECT 116.610 99.010 117.520 104.010 ;
        RECT 127.520 99.010 128.430 104.010 ;
        RECT 138.430 99.010 141.430 104.010 ;
        RECT 183.200 99.010 185.700 104.010 ;
        RECT 195.700 99.010 196.610 104.010 ;
        RECT 206.610 99.010 207.520 104.010 ;
        RECT 217.520 99.010 218.430 104.010 ;
        RECT 228.430 99.010 229.340 104.010 ;
        RECT 239.340 99.010 240.250 104.010 ;
        RECT 250.250 99.010 251.160 104.010 ;
        RECT 261.160 99.010 262.070 104.010 ;
        RECT 272.070 99.010 272.980 104.010 ;
        RECT 282.980 99.010 283.890 104.010 ;
        RECT 293.890 99.010 294.800 104.010 ;
        RECT 304.800 99.010 305.800 104.010 ;
        RECT 8.200 97.250 13.200 97.680 ;
        RECT 31.200 91.350 35.700 96.350 ;
        RECT 45.700 91.350 46.610 96.350 ;
        RECT 56.610 91.350 57.610 96.350 ;
        RECT 95.200 91.350 95.700 96.350 ;
        RECT 105.700 91.350 106.610 96.350 ;
        RECT 116.610 91.350 117.520 96.350 ;
        RECT 127.520 91.350 128.430 96.350 ;
        RECT 138.430 91.350 141.430 96.350 ;
        RECT 183.200 91.350 185.700 96.350 ;
        RECT 195.700 91.350 196.610 96.350 ;
        RECT 206.610 91.350 207.520 96.350 ;
        RECT 217.520 91.350 218.430 96.350 ;
        RECT 228.430 91.350 229.340 96.350 ;
        RECT 239.340 91.350 240.250 96.350 ;
        RECT 250.250 91.350 251.160 96.350 ;
        RECT 261.160 91.350 262.070 96.350 ;
        RECT 272.070 91.350 272.980 96.350 ;
        RECT 282.980 91.350 283.890 96.350 ;
        RECT 293.890 91.350 294.800 96.350 ;
        RECT 304.800 91.350 305.800 96.350 ;
        RECT 31.200 85.970 35.700 90.970 ;
        RECT 45.700 85.970 46.610 90.970 ;
        RECT 56.610 85.970 57.610 90.970 ;
        RECT 95.200 85.970 95.700 90.970 ;
        RECT 105.700 85.970 106.610 90.970 ;
        RECT 116.610 85.970 117.520 90.970 ;
        RECT 127.520 85.970 128.430 90.970 ;
        RECT 138.430 85.970 141.430 90.970 ;
        RECT 183.200 85.970 185.700 90.970 ;
        RECT 195.700 85.970 196.610 90.970 ;
        RECT 206.610 85.970 207.520 90.970 ;
        RECT 217.520 85.970 218.430 90.970 ;
        RECT 228.430 85.970 229.340 90.970 ;
        RECT 239.340 85.970 240.250 90.970 ;
        RECT 250.250 85.970 251.160 90.970 ;
        RECT 261.160 85.970 262.070 90.970 ;
        RECT 272.070 85.970 272.980 90.970 ;
        RECT 282.980 85.970 283.890 90.970 ;
        RECT 293.890 85.970 294.800 90.970 ;
        RECT 304.800 85.970 305.800 90.970 ;
        RECT 31.200 80.590 35.700 85.590 ;
        RECT 45.700 80.590 46.610 85.590 ;
        RECT 56.610 80.590 57.610 85.590 ;
        RECT 95.200 80.590 95.700 85.590 ;
        RECT 105.700 80.590 106.610 85.590 ;
        RECT 116.610 80.590 117.520 85.590 ;
        RECT 127.520 80.590 128.430 85.590 ;
        RECT 138.430 80.590 141.430 85.590 ;
        RECT 183.200 80.590 185.700 85.590 ;
        RECT 195.700 80.590 196.610 85.590 ;
        RECT 206.610 80.590 207.520 85.590 ;
        RECT 217.520 80.590 218.430 85.590 ;
        RECT 228.430 80.590 229.340 85.590 ;
        RECT 239.340 80.590 240.250 85.590 ;
        RECT 250.250 80.590 251.160 85.590 ;
        RECT 261.160 80.590 262.070 85.590 ;
        RECT 272.070 80.590 272.980 85.590 ;
        RECT 282.980 80.590 283.890 85.590 ;
        RECT 293.890 80.590 294.800 85.590 ;
        RECT 304.800 80.590 305.800 85.590 ;
        RECT 31.200 75.210 35.700 80.210 ;
        RECT 45.700 75.210 46.610 80.210 ;
        RECT 56.610 75.210 57.610 80.210 ;
        RECT 95.200 75.210 95.700 80.210 ;
        RECT 105.700 75.210 106.610 80.210 ;
        RECT 116.610 75.210 117.520 80.210 ;
        RECT 127.520 75.210 128.430 80.210 ;
        RECT 138.430 75.210 141.430 80.210 ;
        RECT 183.200 75.210 185.700 80.210 ;
        RECT 195.700 75.210 196.610 80.210 ;
        RECT 206.610 75.210 207.520 80.210 ;
        RECT 217.520 75.210 218.430 80.210 ;
        RECT 228.430 75.210 229.340 80.210 ;
        RECT 239.340 75.210 240.250 80.210 ;
        RECT 250.250 75.210 251.160 80.210 ;
        RECT 261.160 75.210 262.070 80.210 ;
        RECT 272.070 75.210 272.980 80.210 ;
        RECT 282.980 75.210 283.890 80.210 ;
        RECT 293.890 75.210 294.800 80.210 ;
        RECT 304.800 75.210 305.800 80.210 ;
        RECT 31.200 67.550 35.700 72.550 ;
        RECT 45.700 67.550 46.610 72.550 ;
        RECT 56.610 67.550 57.610 72.550 ;
        RECT 95.200 67.550 95.700 72.550 ;
        RECT 105.700 67.550 106.610 72.550 ;
        RECT 116.610 67.550 117.520 72.550 ;
        RECT 127.520 67.550 128.430 72.550 ;
        RECT 138.430 67.550 141.430 72.550 ;
        RECT 183.200 67.550 185.700 72.550 ;
        RECT 195.700 67.550 196.610 72.550 ;
        RECT 206.610 67.550 207.520 72.550 ;
        RECT 217.520 67.550 218.430 72.550 ;
        RECT 228.430 67.550 229.340 72.550 ;
        RECT 239.340 67.550 240.250 72.550 ;
        RECT 250.250 67.550 251.160 72.550 ;
        RECT 261.160 67.550 262.070 72.550 ;
        RECT 272.070 67.550 272.980 72.550 ;
        RECT 282.980 67.550 283.890 72.550 ;
        RECT 293.890 67.550 294.800 72.550 ;
        RECT 304.800 67.550 305.800 72.550 ;
        RECT 31.200 62.170 35.700 67.170 ;
        RECT 45.700 62.170 46.610 67.170 ;
        RECT 56.610 62.170 57.610 67.170 ;
        RECT 95.200 62.170 95.700 67.170 ;
        RECT 105.700 62.170 106.610 67.170 ;
        RECT 116.610 62.170 117.520 67.170 ;
        RECT 127.520 62.170 128.430 67.170 ;
        RECT 138.430 62.170 141.430 67.170 ;
        RECT 183.200 62.170 185.700 67.170 ;
        RECT 195.700 62.170 196.610 67.170 ;
        RECT 206.610 62.170 207.520 67.170 ;
        RECT 217.520 62.170 218.430 67.170 ;
        RECT 228.430 62.170 229.340 67.170 ;
        RECT 239.340 62.170 240.250 67.170 ;
        RECT 250.250 62.170 251.160 67.170 ;
        RECT 261.160 62.170 262.070 67.170 ;
        RECT 272.070 62.170 272.980 67.170 ;
        RECT 282.980 62.170 283.890 67.170 ;
        RECT 293.890 62.170 294.800 67.170 ;
        RECT 304.800 62.170 305.800 67.170 ;
        RECT 31.200 56.790 35.700 61.790 ;
        RECT 45.700 56.790 46.610 61.790 ;
        RECT 56.610 56.790 57.610 61.790 ;
        RECT 95.200 56.790 95.700 61.790 ;
        RECT 105.700 56.790 106.610 61.790 ;
        RECT 116.610 56.790 117.520 61.790 ;
        RECT 127.520 56.790 128.430 61.790 ;
        RECT 138.430 56.790 141.430 61.790 ;
        RECT 183.200 56.790 185.700 61.790 ;
        RECT 195.700 56.790 196.610 61.790 ;
        RECT 206.610 56.790 207.520 61.790 ;
        RECT 217.520 56.790 218.430 61.790 ;
        RECT 228.430 56.790 229.340 61.790 ;
        RECT 239.340 56.790 240.250 61.790 ;
        RECT 250.250 56.790 251.160 61.790 ;
        RECT 261.160 56.790 262.070 61.790 ;
        RECT 272.070 56.790 272.980 61.790 ;
        RECT 282.980 56.790 283.890 61.790 ;
        RECT 293.890 56.790 294.800 61.790 ;
        RECT 304.800 56.790 305.800 61.790 ;
        RECT 31.200 51.410 35.700 56.410 ;
        RECT 45.700 51.410 46.610 56.410 ;
        RECT 56.610 51.410 57.610 56.410 ;
        RECT 95.200 51.410 95.700 56.410 ;
        RECT 105.700 51.410 106.610 56.410 ;
        RECT 116.610 51.410 117.520 56.410 ;
        RECT 127.520 51.410 128.430 56.410 ;
        RECT 138.430 51.410 141.430 56.410 ;
        RECT 183.200 51.410 185.700 56.410 ;
        RECT 195.700 51.410 196.610 56.410 ;
        RECT 206.610 51.410 207.520 56.410 ;
        RECT 217.520 51.410 218.430 56.410 ;
        RECT 228.430 51.410 229.340 56.410 ;
        RECT 239.340 51.410 240.250 56.410 ;
        RECT 250.250 51.410 251.160 56.410 ;
        RECT 261.160 51.410 262.070 56.410 ;
        RECT 272.070 51.410 272.980 56.410 ;
        RECT 282.980 51.410 283.890 56.410 ;
        RECT 293.890 51.410 294.800 56.410 ;
        RECT 304.800 51.410 305.800 56.410 ;
        RECT 31.200 43.750 35.700 48.750 ;
        RECT 45.700 43.750 46.610 48.750 ;
        RECT 56.610 43.750 57.610 48.750 ;
        RECT 95.200 43.750 95.700 48.750 ;
        RECT 105.700 43.750 106.610 48.750 ;
        RECT 116.610 43.750 117.520 48.750 ;
        RECT 127.520 43.750 128.430 48.750 ;
        RECT 138.430 43.750 141.430 48.750 ;
        RECT 183.200 43.750 185.700 48.750 ;
        RECT 195.700 43.750 196.610 48.750 ;
        RECT 206.610 43.750 207.520 48.750 ;
        RECT 217.520 43.750 218.430 48.750 ;
        RECT 228.430 43.750 229.340 48.750 ;
        RECT 239.340 43.750 240.250 48.750 ;
        RECT 250.250 43.750 251.160 48.750 ;
        RECT 261.160 43.750 262.070 48.750 ;
        RECT 272.070 43.750 272.980 48.750 ;
        RECT 282.980 43.750 283.890 48.750 ;
        RECT 293.890 43.750 294.800 48.750 ;
        RECT 304.800 43.750 305.800 48.750 ;
        RECT 31.200 38.370 35.700 43.370 ;
        RECT 45.700 38.370 46.610 43.370 ;
        RECT 56.610 38.370 57.610 43.370 ;
        RECT 95.200 38.370 95.700 43.370 ;
        RECT 105.700 38.370 106.610 43.370 ;
        RECT 116.610 38.370 117.520 43.370 ;
        RECT 127.520 38.370 128.430 43.370 ;
        RECT 138.430 38.370 141.430 43.370 ;
        RECT 183.200 38.370 185.700 43.370 ;
        RECT 195.700 38.370 196.610 43.370 ;
        RECT 206.610 38.370 207.520 43.370 ;
        RECT 217.520 38.370 218.430 43.370 ;
        RECT 228.430 38.370 229.340 43.370 ;
        RECT 239.340 38.370 240.250 43.370 ;
        RECT 250.250 38.370 251.160 43.370 ;
        RECT 261.160 38.370 262.070 43.370 ;
        RECT 272.070 38.370 272.980 43.370 ;
        RECT 282.980 38.370 283.890 43.370 ;
        RECT 293.890 38.370 294.800 43.370 ;
        RECT 304.800 38.370 305.800 43.370 ;
        RECT 31.200 32.990 35.700 37.990 ;
        RECT 45.700 32.990 46.610 37.990 ;
        RECT 56.610 32.990 57.610 37.990 ;
        RECT 95.200 32.990 95.700 37.990 ;
        RECT 105.700 32.990 106.610 37.990 ;
        RECT 116.610 32.990 117.520 37.990 ;
        RECT 127.520 32.990 128.430 37.990 ;
        RECT 138.430 32.990 141.430 37.990 ;
        RECT 183.200 32.990 185.700 37.990 ;
        RECT 195.700 32.990 196.610 37.990 ;
        RECT 206.610 32.990 207.520 37.990 ;
        RECT 217.520 32.990 218.430 37.990 ;
        RECT 228.430 32.990 229.340 37.990 ;
        RECT 239.340 32.990 240.250 37.990 ;
        RECT 250.250 32.990 251.160 37.990 ;
        RECT 261.160 32.990 262.070 37.990 ;
        RECT 272.070 32.990 272.980 37.990 ;
        RECT 282.980 32.990 283.890 37.990 ;
        RECT 293.890 32.990 294.800 37.990 ;
        RECT 304.800 32.990 305.800 37.990 ;
        RECT 31.200 27.610 35.700 32.610 ;
        RECT 45.700 27.610 46.610 32.610 ;
        RECT 56.610 27.610 57.610 32.610 ;
        RECT 95.200 27.610 95.700 32.610 ;
        RECT 105.700 27.610 106.610 32.610 ;
        RECT 116.610 27.610 117.520 32.610 ;
        RECT 127.520 27.610 128.430 32.610 ;
        RECT 138.430 27.610 141.430 32.610 ;
        RECT 183.200 27.610 185.700 32.610 ;
        RECT 195.700 27.610 196.610 32.610 ;
        RECT 206.610 27.610 207.520 32.610 ;
        RECT 217.520 27.610 218.430 32.610 ;
        RECT 228.430 27.610 229.340 32.610 ;
        RECT 239.340 27.610 240.250 32.610 ;
        RECT 250.250 27.610 251.160 32.610 ;
        RECT 261.160 27.610 262.070 32.610 ;
        RECT 272.070 27.610 272.980 32.610 ;
        RECT 282.980 27.610 283.890 32.610 ;
        RECT 293.890 27.610 294.800 32.610 ;
        RECT 304.800 27.610 305.800 32.610 ;
        RECT 31.200 19.950 35.700 24.950 ;
        RECT 45.700 19.950 46.610 24.950 ;
        RECT 56.610 19.950 57.610 24.950 ;
        RECT 95.200 19.950 95.700 24.950 ;
        RECT 105.700 19.950 106.610 24.950 ;
        RECT 116.610 19.950 117.520 24.950 ;
        RECT 127.520 19.950 128.430 24.950 ;
        RECT 138.430 19.950 141.430 24.950 ;
        RECT 183.200 19.950 185.700 24.950 ;
        RECT 195.700 19.950 196.610 24.950 ;
        RECT 206.610 19.950 207.520 24.950 ;
        RECT 217.520 19.950 218.430 24.950 ;
        RECT 228.430 19.950 229.340 24.950 ;
        RECT 239.340 19.950 240.250 24.950 ;
        RECT 250.250 19.950 251.160 24.950 ;
        RECT 261.160 19.950 262.070 24.950 ;
        RECT 272.070 19.950 272.980 24.950 ;
        RECT 282.980 19.950 283.890 24.950 ;
        RECT 293.890 19.950 294.800 24.950 ;
        RECT 304.800 19.950 305.800 24.950 ;
        RECT 31.200 14.570 35.700 19.570 ;
        RECT 45.700 14.570 46.610 19.570 ;
        RECT 56.610 14.570 57.610 19.570 ;
        RECT 95.200 14.570 95.700 19.570 ;
        RECT 105.700 14.570 106.610 19.570 ;
        RECT 116.610 14.570 117.520 19.570 ;
        RECT 127.520 14.570 128.430 19.570 ;
        RECT 138.430 14.570 141.430 19.570 ;
        RECT 183.200 14.570 185.700 19.570 ;
        RECT 195.700 14.570 196.610 19.570 ;
        RECT 206.610 14.570 207.520 19.570 ;
        RECT 217.520 14.570 218.430 19.570 ;
        RECT 228.430 14.570 229.340 19.570 ;
        RECT 239.340 14.570 240.250 19.570 ;
        RECT 250.250 14.570 251.160 19.570 ;
        RECT 261.160 14.570 262.070 19.570 ;
        RECT 272.070 14.570 272.980 19.570 ;
        RECT 282.980 14.570 283.890 19.570 ;
        RECT 293.890 14.570 294.800 19.570 ;
        RECT 304.800 14.570 305.800 19.570 ;
        RECT 31.200 9.190 35.700 14.190 ;
        RECT 45.700 9.190 46.610 14.190 ;
        RECT 56.610 9.190 57.610 14.190 ;
        RECT 95.200 9.190 95.700 14.190 ;
        RECT 105.700 9.190 106.610 14.190 ;
        RECT 116.610 9.190 117.520 14.190 ;
        RECT 127.520 9.190 128.430 14.190 ;
        RECT 138.430 9.190 141.430 14.190 ;
        RECT 183.200 9.190 185.700 14.190 ;
        RECT 195.700 9.190 196.610 14.190 ;
        RECT 206.610 9.190 207.520 14.190 ;
        RECT 217.520 9.190 218.430 14.190 ;
        RECT 228.430 9.190 229.340 14.190 ;
        RECT 239.340 9.190 240.250 14.190 ;
        RECT 250.250 9.190 251.160 14.190 ;
        RECT 261.160 9.190 262.070 14.190 ;
        RECT 272.070 9.190 272.980 14.190 ;
        RECT 282.980 9.190 283.890 14.190 ;
        RECT 293.890 9.190 294.800 14.190 ;
        RECT 304.800 9.190 305.800 14.190 ;
        RECT 31.200 3.810 35.700 8.810 ;
        RECT 45.700 3.810 46.610 8.810 ;
        RECT 56.610 3.810 57.610 8.810 ;
        RECT 95.200 3.810 95.700 8.810 ;
        RECT 105.700 3.810 106.610 8.810 ;
        RECT 116.610 3.810 117.520 8.810 ;
        RECT 127.520 3.810 128.430 8.810 ;
        RECT 138.430 3.810 141.430 8.810 ;
        RECT 183.200 3.810 185.700 8.810 ;
        RECT 195.700 3.810 196.610 8.810 ;
        RECT 206.610 3.810 207.520 8.810 ;
        RECT 217.520 3.810 218.430 8.810 ;
        RECT 228.430 3.810 229.340 8.810 ;
        RECT 239.340 3.810 240.250 8.810 ;
        RECT 250.250 3.810 251.160 8.810 ;
        RECT 261.160 3.810 262.070 8.810 ;
        RECT 272.070 3.810 272.980 8.810 ;
        RECT 282.980 3.810 283.890 8.810 ;
        RECT 293.890 3.810 294.800 8.810 ;
        RECT 304.800 3.810 305.800 8.810 ;
      LAYER Metal1 ;
        RECT 23.515 194.180 70.015 194.680 ;
        RECT 23.515 189.980 24.115 194.180 ;
        RECT 25.065 192.630 68.165 193.130 ;
        RECT 23.315 171.980 24.315 189.980 ;
        RECT 25.065 186.680 25.665 192.630 ;
        RECT 35.200 191.420 61.110 192.060 ;
        RECT 32.100 188.650 32.870 189.450 ;
        RECT 67.565 186.680 68.165 192.630 ;
        RECT 69.415 189.980 70.015 194.180 ;
        RECT 83.545 194.180 151.805 194.680 ;
        RECT 83.545 189.980 84.145 194.180 ;
        RECT 85.095 192.630 149.955 193.130 ;
        RECT 24.975 186.040 68.255 186.680 ;
        RECT 25.065 175.920 25.665 186.040 ;
        RECT 32.100 183.270 32.870 184.070 ;
        RECT 35.200 180.660 61.110 181.300 ;
        RECT 32.100 177.890 32.870 178.690 ;
        RECT 67.565 175.920 68.165 186.040 ;
        RECT 24.975 175.280 68.255 175.920 ;
        RECT 23.515 142.380 24.115 171.980 ;
        RECT 25.065 169.330 25.665 175.280 ;
        RECT 32.100 172.510 32.870 173.310 ;
        RECT 35.200 169.900 61.110 170.540 ;
        RECT 67.565 169.330 68.165 175.280 ;
        RECT 68.915 171.980 70.015 189.980 ;
        RECT 83.345 171.980 84.345 189.980 ;
        RECT 25.065 168.830 68.165 169.330 ;
        RECT 25.065 166.180 25.665 168.830 ;
        RECT 35.200 167.620 61.110 168.260 ;
        RECT 67.565 166.180 68.165 168.830 ;
        RECT 24.865 162.880 25.865 166.180 ;
        RECT 32.100 164.850 32.870 165.650 ;
        RECT 67.365 162.880 68.365 166.180 ;
        RECT 24.865 162.240 68.365 162.880 ;
        RECT 24.865 152.120 25.865 162.240 ;
        RECT 32.100 159.470 32.870 160.270 ;
        RECT 35.200 156.860 61.110 157.500 ;
        RECT 32.100 154.090 32.870 154.890 ;
        RECT 67.365 152.120 68.365 162.240 ;
        RECT 24.865 151.480 68.365 152.120 ;
        RECT 24.865 148.180 25.865 151.480 ;
        RECT 32.100 148.710 32.870 149.510 ;
        RECT 67.365 148.180 68.365 151.480 ;
        RECT 25.065 145.530 25.665 148.180 ;
        RECT 35.200 146.100 61.110 146.740 ;
        RECT 67.565 145.530 68.165 148.180 ;
        RECT 25.065 145.030 68.165 145.530 ;
        RECT 1.890 140.150 2.890 142.380 ;
        RECT 19.290 140.150 20.290 142.380 ;
        RECT 1.890 139.650 20.370 140.150 ;
        RECT 1.890 124.380 2.890 139.650 ;
        RECT 5.090 136.650 17.250 137.150 ;
        RECT 2.090 90.850 2.690 124.380 ;
        RECT 5.090 118.580 5.690 136.650 ;
        RECT 7.715 133.685 13.425 135.120 ;
        RECT 16.650 118.580 17.250 136.650 ;
        RECT 19.290 124.380 20.370 139.650 ;
        RECT 23.315 124.380 24.315 142.380 ;
        RECT 25.065 139.080 25.665 145.030 ;
        RECT 35.200 143.820 61.110 144.460 ;
        RECT 32.100 141.050 32.870 141.850 ;
        RECT 67.565 139.080 68.165 145.030 ;
        RECT 69.415 142.380 70.015 171.980 ;
        RECT 83.545 142.380 84.145 171.980 ;
        RECT 85.095 169.330 85.695 192.630 ;
        RECT 95.200 191.420 142.930 192.060 ;
        RECT 139.760 188.650 140.530 189.450 ;
        RECT 92.700 186.040 139.430 186.680 ;
        RECT 139.760 183.270 140.530 184.070 ;
        RECT 95.200 180.660 142.930 181.300 ;
        RECT 139.760 177.890 140.530 178.690 ;
        RECT 92.700 175.280 139.430 175.920 ;
        RECT 139.760 172.510 140.530 173.310 ;
        RECT 95.200 169.900 142.930 170.540 ;
        RECT 149.355 169.330 149.955 192.630 ;
        RECT 151.205 189.980 151.805 194.180 ;
        RECT 173.650 194.180 318.070 194.680 ;
        RECT 151.005 171.980 152.005 189.980 ;
        RECT 85.095 168.830 149.955 169.330 ;
        RECT 85.095 166.180 85.695 168.830 ;
        RECT 95.200 167.620 142.930 168.260 ;
        RECT 149.355 166.180 149.955 168.830 ;
        RECT 84.895 148.180 85.895 166.180 ;
        RECT 139.760 164.850 140.530 165.650 ;
        RECT 92.700 162.240 139.430 162.880 ;
        RECT 139.760 159.470 140.530 160.270 ;
        RECT 95.200 156.860 142.930 157.500 ;
        RECT 139.760 154.090 140.530 154.890 ;
        RECT 92.700 151.480 139.430 152.120 ;
        RECT 139.760 148.710 140.530 149.510 ;
        RECT 149.155 148.180 150.155 166.180 ;
        RECT 85.095 145.530 85.695 148.180 ;
        RECT 95.200 146.100 142.930 146.740 ;
        RECT 149.355 145.530 149.955 148.180 ;
        RECT 85.095 145.030 149.955 145.530 ;
        RECT 24.975 138.440 68.255 139.080 ;
        RECT 25.065 128.320 25.665 138.440 ;
        RECT 32.100 135.670 32.870 136.470 ;
        RECT 35.200 133.060 61.110 133.700 ;
        RECT 32.100 130.290 32.870 131.090 ;
        RECT 67.565 128.320 68.165 138.440 ;
        RECT 24.975 127.680 68.255 128.320 ;
        RECT 4.890 100.580 5.890 118.580 ;
        RECT 16.290 100.580 17.290 118.580 ;
        RECT 5.090 93.630 5.690 100.580 ;
        RECT 7.595 96.050 13.780 97.985 ;
        RECT 16.650 93.630 17.250 100.580 ;
        RECT 5.090 93.130 17.250 93.630 ;
        RECT 19.770 90.850 20.370 124.380 ;
        RECT 23.515 94.780 24.115 124.380 ;
        RECT 25.065 121.730 25.665 127.680 ;
        RECT 32.100 124.910 32.870 125.710 ;
        RECT 35.200 122.300 61.110 122.940 ;
        RECT 67.565 121.730 68.165 127.680 ;
        RECT 68.915 124.380 70.015 142.380 ;
        RECT 83.345 124.380 84.345 142.380 ;
        RECT 25.065 121.230 68.165 121.730 ;
        RECT 25.065 118.580 25.665 121.230 ;
        RECT 31.200 120.020 45.800 120.660 ;
        RECT 46.400 120.020 61.110 120.660 ;
        RECT 67.565 118.580 68.165 121.230 ;
        RECT 24.865 115.280 25.865 118.580 ;
        RECT 32.100 117.250 32.870 118.050 ;
        RECT 67.365 115.280 68.365 118.580 ;
        RECT 24.865 114.640 68.365 115.280 ;
        RECT 24.865 104.520 25.865 114.640 ;
        RECT 32.100 111.870 32.870 112.670 ;
        RECT 31.200 109.260 45.800 109.900 ;
        RECT 46.400 109.260 61.110 109.900 ;
        RECT 32.100 106.490 32.870 107.290 ;
        RECT 67.365 104.520 68.365 114.640 ;
        RECT 24.865 103.880 68.365 104.520 ;
        RECT 24.865 100.580 25.865 103.880 ;
        RECT 32.100 101.110 32.870 101.910 ;
        RECT 67.365 100.580 68.365 103.880 ;
        RECT 25.065 97.930 25.665 100.580 ;
        RECT 31.200 98.500 45.800 99.140 ;
        RECT 46.400 98.500 61.110 99.140 ;
        RECT 67.565 97.930 68.165 100.580 ;
        RECT 25.065 97.430 68.165 97.930 ;
        RECT 2.090 90.350 20.370 90.850 ;
        RECT 23.315 76.780 24.315 94.780 ;
        RECT 25.065 91.480 25.665 97.430 ;
        RECT 31.200 96.220 45.800 96.860 ;
        RECT 46.400 96.220 61.110 96.860 ;
        RECT 32.100 93.450 32.870 94.250 ;
        RECT 67.565 91.480 68.165 97.430 ;
        RECT 69.415 94.780 70.015 124.380 ;
        RECT 83.545 94.780 84.145 124.380 ;
        RECT 85.095 121.730 85.695 145.030 ;
        RECT 95.200 143.820 142.930 144.460 ;
        RECT 139.760 141.050 140.530 141.850 ;
        RECT 92.700 138.440 139.430 139.080 ;
        RECT 139.760 135.670 140.530 136.470 ;
        RECT 95.200 133.060 142.930 133.700 ;
        RECT 139.760 130.290 140.530 131.090 ;
        RECT 92.700 127.680 139.430 128.320 ;
        RECT 139.760 124.910 140.530 125.710 ;
        RECT 95.200 122.300 142.930 122.940 ;
        RECT 149.355 121.730 149.955 145.030 ;
        RECT 151.205 142.380 151.805 171.980 ;
        RECT 173.650 166.180 174.250 194.180 ;
        RECT 175.200 192.630 316.220 193.130 ;
        RECT 175.200 189.980 175.800 192.630 ;
        RECT 182.700 191.420 309.300 192.060 ;
        RECT 315.620 189.980 316.220 192.630 ;
        RECT 175.000 186.680 176.000 189.980 ;
        RECT 184.100 188.650 184.870 189.450 ;
        RECT 315.420 186.680 316.420 189.980 ;
        RECT 175.000 186.040 316.420 186.680 ;
        RECT 175.000 175.920 176.000 186.040 ;
        RECT 184.100 183.270 184.870 184.070 ;
        RECT 182.700 180.660 312.300 181.300 ;
        RECT 184.100 177.890 184.870 178.690 ;
        RECT 315.420 175.920 316.420 186.040 ;
        RECT 175.000 175.280 316.420 175.920 ;
        RECT 175.000 171.980 176.000 175.280 ;
        RECT 184.100 172.510 184.870 173.310 ;
        RECT 315.420 171.980 316.420 175.280 ;
        RECT 175.200 169.330 175.800 171.980 ;
        RECT 182.700 169.900 309.300 170.540 ;
        RECT 315.620 169.330 316.220 171.980 ;
        RECT 175.200 168.830 316.220 169.330 ;
        RECT 173.450 148.180 174.450 166.180 ;
        RECT 175.200 162.880 175.800 168.830 ;
        RECT 182.700 167.620 312.300 168.260 ;
        RECT 184.100 164.850 184.870 165.650 ;
        RECT 315.620 162.880 316.220 168.830 ;
        RECT 317.470 166.180 318.070 194.180 ;
        RECT 175.110 162.240 316.310 162.880 ;
        RECT 175.200 152.120 175.800 162.240 ;
        RECT 184.100 159.470 184.870 160.270 ;
        RECT 182.700 156.860 309.300 157.500 ;
        RECT 184.100 154.090 184.870 154.890 ;
        RECT 315.620 152.120 316.220 162.240 ;
        RECT 175.110 151.480 316.310 152.120 ;
        RECT 151.005 124.380 152.005 142.380 ;
        RECT 85.095 121.230 149.955 121.730 ;
        RECT 85.095 118.580 85.695 121.230 ;
        RECT 95.200 120.020 142.930 120.660 ;
        RECT 149.355 118.580 149.955 121.230 ;
        RECT 84.895 100.580 85.895 118.580 ;
        RECT 139.760 117.250 140.530 118.050 ;
        RECT 92.700 114.640 139.430 115.280 ;
        RECT 139.760 111.870 140.530 112.670 ;
        RECT 95.200 109.260 142.930 109.900 ;
        RECT 139.760 106.490 140.530 107.290 ;
        RECT 92.700 103.880 139.430 104.520 ;
        RECT 139.760 101.110 140.530 101.910 ;
        RECT 149.155 100.580 150.155 118.580 ;
        RECT 85.095 97.930 85.695 100.580 ;
        RECT 95.200 98.500 142.930 99.140 ;
        RECT 149.355 97.930 149.955 100.580 ;
        RECT 85.095 97.430 149.955 97.930 ;
        RECT 24.975 90.840 68.255 91.480 ;
        RECT 25.065 80.720 25.665 90.840 ;
        RECT 32.100 88.070 32.870 88.870 ;
        RECT 31.200 85.460 45.800 86.100 ;
        RECT 46.400 85.460 61.110 86.100 ;
        RECT 32.100 82.690 32.870 83.490 ;
        RECT 67.565 80.720 68.165 90.840 ;
        RECT 24.975 80.080 68.255 80.720 ;
        RECT 23.515 47.180 24.115 76.780 ;
        RECT 25.065 74.130 25.665 80.080 ;
        RECT 32.100 77.310 32.870 78.110 ;
        RECT 31.200 74.700 45.800 75.340 ;
        RECT 46.400 74.700 61.110 75.340 ;
        RECT 67.565 74.130 68.165 80.080 ;
        RECT 68.915 76.780 70.015 94.780 ;
        RECT 83.345 76.780 84.345 94.780 ;
        RECT 25.065 73.630 68.165 74.130 ;
        RECT 25.065 70.980 25.665 73.630 ;
        RECT 35.200 72.420 61.110 73.060 ;
        RECT 67.565 70.980 68.165 73.630 ;
        RECT 24.865 67.680 25.865 70.980 ;
        RECT 32.100 69.650 32.870 70.450 ;
        RECT 67.365 67.680 68.365 70.980 ;
        RECT 24.865 67.040 68.365 67.680 ;
        RECT 24.865 56.920 25.865 67.040 ;
        RECT 32.100 64.270 32.870 65.070 ;
        RECT 35.200 61.660 61.110 62.300 ;
        RECT 32.100 58.890 32.870 59.690 ;
        RECT 67.365 56.920 68.365 67.040 ;
        RECT 24.865 56.280 68.365 56.920 ;
        RECT 24.865 52.980 25.865 56.280 ;
        RECT 32.100 53.510 32.870 54.310 ;
        RECT 67.365 52.980 68.365 56.280 ;
        RECT 25.065 50.330 25.665 52.980 ;
        RECT 35.200 50.900 61.110 51.540 ;
        RECT 67.565 50.330 68.165 52.980 ;
        RECT 25.065 49.830 68.165 50.330 ;
        RECT 23.315 29.180 24.315 47.180 ;
        RECT 25.065 43.880 25.665 49.830 ;
        RECT 35.200 48.620 61.110 49.260 ;
        RECT 32.100 45.850 32.870 46.650 ;
        RECT 67.565 43.880 68.165 49.830 ;
        RECT 69.415 47.180 70.015 76.780 ;
        RECT 83.545 47.180 84.145 76.780 ;
        RECT 85.095 74.130 85.695 97.430 ;
        RECT 95.200 96.220 142.930 96.860 ;
        RECT 139.760 93.450 140.530 94.250 ;
        RECT 92.700 90.840 139.430 91.480 ;
        RECT 139.760 88.070 140.530 88.870 ;
        RECT 95.200 85.460 142.930 86.100 ;
        RECT 139.760 82.690 140.530 83.490 ;
        RECT 92.700 80.080 139.430 80.720 ;
        RECT 139.760 77.310 140.530 78.110 ;
        RECT 95.200 74.700 142.930 75.340 ;
        RECT 149.355 74.130 149.955 97.430 ;
        RECT 151.205 94.780 151.805 124.380 ;
        RECT 173.650 118.580 174.250 148.180 ;
        RECT 175.200 145.530 175.800 151.480 ;
        RECT 184.100 148.710 184.870 149.510 ;
        RECT 182.700 146.100 312.300 146.740 ;
        RECT 315.620 145.530 316.220 151.480 ;
        RECT 317.270 148.180 318.270 166.180 ;
        RECT 175.200 145.030 316.220 145.530 ;
        RECT 175.200 142.380 175.800 145.030 ;
        RECT 182.700 143.820 309.300 144.460 ;
        RECT 315.620 142.380 316.220 145.030 ;
        RECT 175.000 139.080 176.000 142.380 ;
        RECT 184.100 141.050 184.870 141.850 ;
        RECT 315.420 139.080 316.420 142.380 ;
        RECT 175.000 138.440 316.420 139.080 ;
        RECT 175.000 128.320 176.000 138.440 ;
        RECT 184.100 135.670 184.870 136.470 ;
        RECT 182.700 133.060 312.300 133.700 ;
        RECT 184.100 130.290 184.870 131.090 ;
        RECT 315.420 128.320 316.420 138.440 ;
        RECT 175.000 127.680 316.420 128.320 ;
        RECT 175.000 124.380 176.000 127.680 ;
        RECT 184.100 124.910 184.870 125.710 ;
        RECT 315.420 124.380 316.420 127.680 ;
        RECT 175.200 121.730 175.800 124.380 ;
        RECT 182.700 122.300 309.300 122.940 ;
        RECT 315.620 121.730 316.220 124.380 ;
        RECT 175.200 121.230 316.220 121.730 ;
        RECT 173.450 100.580 174.450 118.580 ;
        RECT 175.200 115.280 175.800 121.230 ;
        RECT 182.700 120.020 312.300 120.660 ;
        RECT 184.100 117.250 184.870 118.050 ;
        RECT 315.620 115.280 316.220 121.230 ;
        RECT 317.470 118.580 318.070 148.180 ;
        RECT 175.110 114.640 316.310 115.280 ;
        RECT 175.200 104.520 175.800 114.640 ;
        RECT 184.100 111.870 184.870 112.670 ;
        RECT 182.700 109.260 309.300 109.900 ;
        RECT 184.100 106.490 184.870 107.290 ;
        RECT 315.620 104.520 316.220 114.640 ;
        RECT 175.110 103.880 316.310 104.520 ;
        RECT 151.005 76.780 152.005 94.780 ;
        RECT 85.095 73.630 149.955 74.130 ;
        RECT 85.095 70.980 85.695 73.630 ;
        RECT 95.200 72.420 142.930 73.060 ;
        RECT 149.355 70.980 149.955 73.630 ;
        RECT 84.895 52.980 85.895 70.980 ;
        RECT 139.760 69.650 140.530 70.450 ;
        RECT 92.700 67.040 139.430 67.680 ;
        RECT 139.760 64.270 140.530 65.070 ;
        RECT 95.200 61.660 142.930 62.300 ;
        RECT 139.760 58.890 140.530 59.690 ;
        RECT 92.700 56.280 139.430 56.920 ;
        RECT 139.760 53.510 140.530 54.310 ;
        RECT 149.155 52.980 150.155 70.980 ;
        RECT 85.095 50.330 85.695 52.980 ;
        RECT 95.200 50.900 142.930 51.540 ;
        RECT 149.355 50.330 149.955 52.980 ;
        RECT 85.095 49.830 149.955 50.330 ;
        RECT 24.975 43.240 68.255 43.880 ;
        RECT 25.065 33.120 25.665 43.240 ;
        RECT 32.100 40.470 32.870 41.270 ;
        RECT 35.200 37.860 61.110 38.500 ;
        RECT 32.100 35.090 32.870 35.890 ;
        RECT 67.565 33.120 68.165 43.240 ;
        RECT 24.975 32.480 68.255 33.120 ;
        RECT 23.515 0.880 24.115 29.180 ;
        RECT 25.065 26.530 25.665 32.480 ;
        RECT 32.100 29.710 32.870 30.510 ;
        RECT 35.200 27.100 61.110 27.740 ;
        RECT 67.565 26.530 68.165 32.480 ;
        RECT 68.915 29.180 70.015 47.180 ;
        RECT 83.345 29.180 84.345 47.180 ;
        RECT 25.065 26.030 68.165 26.530 ;
        RECT 25.065 23.380 25.665 26.030 ;
        RECT 35.200 24.820 61.110 25.460 ;
        RECT 67.565 23.380 68.165 26.030 ;
        RECT 24.865 20.080 25.865 23.380 ;
        RECT 32.100 22.050 32.870 22.850 ;
        RECT 67.365 20.080 68.365 23.380 ;
        RECT 24.865 19.440 68.365 20.080 ;
        RECT 24.865 9.320 25.865 19.440 ;
        RECT 32.100 16.670 32.870 17.470 ;
        RECT 35.200 14.060 61.110 14.700 ;
        RECT 32.100 11.290 32.870 12.090 ;
        RECT 67.365 9.320 68.365 19.440 ;
        RECT 24.865 8.680 68.365 9.320 ;
        RECT 24.865 5.380 25.865 8.680 ;
        RECT 32.100 5.910 32.870 6.710 ;
        RECT 67.365 5.380 68.365 8.680 ;
        RECT 25.065 2.730 25.665 5.380 ;
        RECT 35.200 3.300 61.110 3.940 ;
        RECT 67.565 2.730 68.165 5.380 ;
        RECT 25.065 2.230 68.165 2.730 ;
        RECT 69.415 0.880 70.015 29.180 ;
        RECT 23.515 0.380 70.015 0.880 ;
        RECT 83.545 0.880 84.145 29.180 ;
        RECT 85.095 26.530 85.695 49.830 ;
        RECT 95.200 48.620 142.930 49.260 ;
        RECT 139.760 45.850 140.530 46.650 ;
        RECT 92.700 43.240 139.430 43.880 ;
        RECT 139.760 40.470 140.530 41.270 ;
        RECT 95.200 37.860 142.930 38.500 ;
        RECT 139.760 35.090 140.530 35.890 ;
        RECT 92.700 32.480 139.430 33.120 ;
        RECT 139.760 29.710 140.530 30.510 ;
        RECT 95.200 27.100 142.930 27.740 ;
        RECT 149.355 26.530 149.955 49.830 ;
        RECT 151.205 47.180 151.805 76.780 ;
        RECT 173.650 70.980 174.250 100.580 ;
        RECT 175.200 97.930 175.800 103.880 ;
        RECT 184.100 101.110 184.870 101.910 ;
        RECT 182.700 98.500 312.300 99.140 ;
        RECT 315.620 97.930 316.220 103.880 ;
        RECT 317.270 100.580 318.270 118.580 ;
        RECT 175.200 97.430 316.220 97.930 ;
        RECT 175.200 94.780 175.800 97.430 ;
        RECT 182.700 96.220 312.300 96.860 ;
        RECT 315.620 94.780 316.220 97.430 ;
        RECT 175.000 91.480 176.000 94.780 ;
        RECT 184.100 93.450 184.870 94.250 ;
        RECT 315.420 91.480 316.420 94.780 ;
        RECT 175.000 90.840 316.420 91.480 ;
        RECT 175.000 80.720 176.000 90.840 ;
        RECT 184.100 88.070 184.870 88.870 ;
        RECT 182.700 85.460 309.300 86.100 ;
        RECT 184.100 82.690 184.870 83.490 ;
        RECT 315.420 80.720 316.420 90.840 ;
        RECT 175.000 80.080 316.420 80.720 ;
        RECT 175.000 76.780 176.000 80.080 ;
        RECT 184.100 77.310 184.870 78.110 ;
        RECT 315.420 76.780 316.420 80.080 ;
        RECT 175.200 74.130 175.800 76.780 ;
        RECT 182.700 74.700 312.300 75.340 ;
        RECT 315.620 74.130 316.220 76.780 ;
        RECT 175.200 73.630 316.220 74.130 ;
        RECT 173.450 52.980 174.450 70.980 ;
        RECT 175.200 67.680 175.800 73.630 ;
        RECT 182.700 72.420 309.300 73.060 ;
        RECT 184.100 69.650 184.870 70.450 ;
        RECT 315.620 67.680 316.220 73.630 ;
        RECT 317.470 70.980 318.070 100.580 ;
        RECT 175.110 67.040 316.310 67.680 ;
        RECT 175.200 56.920 175.800 67.040 ;
        RECT 184.100 64.270 184.870 65.070 ;
        RECT 182.700 61.660 312.300 62.300 ;
        RECT 184.100 58.890 184.870 59.690 ;
        RECT 315.620 56.920 316.220 67.040 ;
        RECT 175.110 56.280 316.310 56.920 ;
        RECT 151.005 29.180 152.005 47.180 ;
        RECT 85.095 26.030 149.955 26.530 ;
        RECT 85.095 23.380 85.695 26.030 ;
        RECT 95.200 24.820 142.930 25.460 ;
        RECT 149.355 23.380 149.955 26.030 ;
        RECT 84.895 5.380 85.895 23.380 ;
        RECT 139.760 22.050 140.530 22.850 ;
        RECT 92.700 19.440 139.430 20.080 ;
        RECT 139.760 16.670 140.530 17.470 ;
        RECT 95.200 14.060 142.930 14.700 ;
        RECT 139.760 11.290 140.530 12.090 ;
        RECT 92.700 8.680 139.430 9.320 ;
        RECT 139.760 5.910 140.530 6.710 ;
        RECT 149.155 5.380 150.155 23.380 ;
        RECT 85.095 2.730 85.695 5.380 ;
        RECT 95.200 3.300 142.930 3.940 ;
        RECT 149.355 2.730 149.955 5.380 ;
        RECT 85.095 2.230 149.955 2.730 ;
        RECT 151.205 0.880 151.805 29.180 ;
        RECT 173.650 23.380 174.250 52.980 ;
        RECT 175.200 50.330 175.800 56.280 ;
        RECT 184.100 53.510 184.870 54.310 ;
        RECT 182.700 50.900 309.300 51.540 ;
        RECT 315.620 50.330 316.220 56.280 ;
        RECT 317.270 52.980 318.270 70.980 ;
        RECT 175.200 49.830 316.220 50.330 ;
        RECT 175.200 47.180 175.800 49.830 ;
        RECT 182.700 48.620 312.300 49.260 ;
        RECT 315.620 47.180 316.220 49.830 ;
        RECT 175.000 43.880 176.000 47.180 ;
        RECT 184.100 45.850 184.870 46.650 ;
        RECT 315.420 43.880 316.420 47.180 ;
        RECT 175.000 43.240 316.420 43.880 ;
        RECT 175.000 33.120 176.000 43.240 ;
        RECT 184.100 40.470 184.870 41.270 ;
        RECT 182.700 37.860 309.300 38.500 ;
        RECT 184.100 35.090 184.870 35.890 ;
        RECT 315.420 33.120 316.420 43.240 ;
        RECT 175.000 32.480 316.420 33.120 ;
        RECT 175.000 29.180 176.000 32.480 ;
        RECT 184.100 29.710 184.870 30.510 ;
        RECT 315.420 29.180 316.420 32.480 ;
        RECT 175.200 26.530 175.800 29.180 ;
        RECT 182.700 27.100 312.300 27.740 ;
        RECT 315.620 26.530 316.220 29.180 ;
        RECT 175.200 26.030 316.220 26.530 ;
        RECT 173.450 5.380 174.450 23.380 ;
        RECT 175.200 20.080 175.800 26.030 ;
        RECT 182.700 24.820 309.300 25.460 ;
        RECT 184.100 22.050 184.870 22.850 ;
        RECT 315.620 20.080 316.220 26.030 ;
        RECT 317.470 23.380 318.070 52.980 ;
        RECT 175.110 19.440 316.310 20.080 ;
        RECT 175.200 9.320 175.800 19.440 ;
        RECT 184.100 16.670 184.870 17.470 ;
        RECT 182.700 14.060 312.300 14.700 ;
        RECT 184.100 11.290 184.870 12.090 ;
        RECT 315.620 9.320 316.220 19.440 ;
        RECT 175.110 8.680 316.310 9.320 ;
        RECT 83.545 0.380 151.805 0.880 ;
        RECT 173.650 0.880 174.250 5.380 ;
        RECT 175.200 2.730 175.800 8.680 ;
        RECT 184.100 5.910 184.870 6.710 ;
        RECT 182.700 3.300 309.300 3.940 ;
        RECT 315.620 2.730 316.220 8.680 ;
        RECT 317.270 5.380 318.270 23.380 ;
        RECT 175.200 2.230 316.220 2.730 ;
        RECT 317.470 0.880 318.070 5.380 ;
        RECT 173.650 0.380 318.070 0.880 ;
      LAYER Metal2 ;
        RECT 58.210 192.060 60.210 192.740 ;
        RECT 23.315 184.480 24.315 187.480 ;
        RECT 23.315 174.480 24.315 177.480 ;
        RECT 24.865 160.680 25.865 163.680 ;
        RECT 24.865 150.680 25.865 153.680 ;
        RECT 1.015 134.390 20.690 140.405 ;
        RECT 23.315 136.880 24.315 139.880 ;
        RECT 1.890 126.880 2.890 129.880 ;
        RECT 19.290 126.880 20.290 129.880 ;
        RECT 23.315 126.880 24.315 129.880 ;
        RECT 32.150 120.840 32.440 192.060 ;
        RECT 58.210 191.420 95.080 192.060 ;
        RECT 140.050 191.540 185.080 191.940 ;
        RECT 58.210 181.300 60.210 191.420 ;
        RECT 68.915 184.480 69.915 187.480 ;
        RECT 83.345 184.480 84.345 187.480 ;
        RECT 93.150 181.300 95.080 191.420 ;
        RECT 140.190 188.640 184.440 189.460 ;
        RECT 151.005 184.480 152.005 187.480 ;
        RECT 175.000 184.480 176.000 187.480 ;
        RECT 140.190 183.260 184.440 184.080 ;
        RECT 58.210 180.660 95.080 181.300 ;
        RECT 140.050 180.780 185.080 181.180 ;
        RECT 58.210 170.540 60.210 180.660 ;
        RECT 68.915 174.480 69.915 177.480 ;
        RECT 83.345 174.480 84.345 177.480 ;
        RECT 93.150 170.540 95.080 180.660 ;
        RECT 140.190 177.880 184.440 178.700 ;
        RECT 151.005 174.480 152.005 177.480 ;
        RECT 175.000 174.480 176.000 177.480 ;
        RECT 140.190 172.500 184.440 173.320 ;
        RECT 58.210 169.900 95.080 170.540 ;
        RECT 140.050 170.020 185.080 170.420 ;
        RECT 58.210 168.260 60.210 169.900 ;
        RECT 93.150 168.260 95.080 169.900 ;
        RECT 58.210 167.620 95.080 168.260 ;
        RECT 140.050 167.740 185.080 168.140 ;
        RECT 58.210 157.500 60.210 167.620 ;
        RECT 67.365 160.680 68.365 163.680 ;
        RECT 84.895 160.680 85.895 163.680 ;
        RECT 93.150 157.500 95.080 167.620 ;
        RECT 140.190 164.840 184.440 165.660 ;
        RECT 149.155 160.680 150.155 163.680 ;
        RECT 173.450 160.680 174.450 163.680 ;
        RECT 140.190 159.460 184.440 160.280 ;
        RECT 58.210 156.860 95.080 157.500 ;
        RECT 140.050 156.980 185.080 157.380 ;
        RECT 58.210 146.740 60.210 156.860 ;
        RECT 67.365 150.680 68.365 153.680 ;
        RECT 84.895 150.680 85.895 153.680 ;
        RECT 93.150 146.740 95.080 156.860 ;
        RECT 140.190 154.080 184.440 154.900 ;
        RECT 149.155 150.680 150.155 153.680 ;
        RECT 173.450 150.680 174.450 153.680 ;
        RECT 140.190 148.700 184.440 149.520 ;
        RECT 58.210 146.100 95.080 146.740 ;
        RECT 140.050 146.220 185.080 146.620 ;
        RECT 58.210 144.460 60.210 146.100 ;
        RECT 93.150 144.460 95.080 146.100 ;
        RECT 58.210 143.820 95.080 144.460 ;
        RECT 140.050 143.940 185.080 144.340 ;
        RECT 58.210 133.700 60.210 143.820 ;
        RECT 68.915 136.880 69.915 139.880 ;
        RECT 83.345 136.880 84.345 139.880 ;
        RECT 93.150 133.700 95.080 143.820 ;
        RECT 140.190 141.040 184.440 141.860 ;
        RECT 151.005 136.880 152.005 139.880 ;
        RECT 175.000 136.880 176.000 139.880 ;
        RECT 140.190 135.660 184.440 136.480 ;
        RECT 58.210 133.060 95.080 133.700 ;
        RECT 140.050 133.180 185.080 133.580 ;
        RECT 58.210 122.940 60.210 133.060 ;
        RECT 68.915 126.880 69.915 129.880 ;
        RECT 83.345 126.880 84.345 129.880 ;
        RECT 93.150 122.940 95.080 133.060 ;
        RECT 140.190 130.280 184.440 131.100 ;
        RECT 151.005 126.880 152.005 129.880 ;
        RECT 175.000 126.880 176.000 129.880 ;
        RECT 140.190 124.900 184.440 125.720 ;
        RECT 58.210 122.300 95.080 122.940 ;
        RECT 140.050 122.420 185.080 122.820 ;
        RECT 4.890 113.080 5.890 116.080 ;
        RECT 16.290 113.080 17.290 116.080 ;
        RECT 24.865 113.080 25.865 116.080 ;
        RECT 4.890 103.080 5.890 106.080 ;
        RECT 16.290 103.080 17.290 106.080 ;
        RECT 24.865 103.080 25.865 106.080 ;
        RECT 31.200 99.765 35.200 120.840 ;
        RECT 7.095 95.760 35.200 99.765 ;
        RECT 23.315 89.280 24.315 92.280 ;
        RECT 23.315 79.280 24.315 82.280 ;
        RECT 31.200 72.240 35.200 95.760 ;
        RECT 58.210 120.660 60.210 122.300 ;
        RECT 93.150 120.660 95.080 122.300 ;
        RECT 58.210 120.020 95.080 120.660 ;
        RECT 140.050 120.140 185.080 120.540 ;
        RECT 58.210 109.900 60.210 120.020 ;
        RECT 67.365 113.080 68.365 116.080 ;
        RECT 84.895 113.080 85.895 116.080 ;
        RECT 93.150 109.900 95.080 120.020 ;
        RECT 140.190 117.240 184.440 118.060 ;
        RECT 149.155 113.080 150.155 116.080 ;
        RECT 173.450 113.080 174.450 116.080 ;
        RECT 140.190 111.860 184.440 112.680 ;
        RECT 58.210 109.260 95.080 109.900 ;
        RECT 140.050 109.380 185.080 109.780 ;
        RECT 58.210 99.140 60.210 109.260 ;
        RECT 67.365 103.080 68.365 106.080 ;
        RECT 84.895 103.080 85.895 106.080 ;
        RECT 93.150 99.140 95.080 109.260 ;
        RECT 140.190 106.480 184.440 107.300 ;
        RECT 149.155 103.080 150.155 106.080 ;
        RECT 173.450 103.080 174.450 106.080 ;
        RECT 140.190 101.100 184.440 101.920 ;
        RECT 58.210 98.500 95.080 99.140 ;
        RECT 140.050 98.620 185.080 99.020 ;
        RECT 58.210 96.860 60.210 98.500 ;
        RECT 93.150 96.860 95.080 98.500 ;
        RECT 58.210 96.220 95.080 96.860 ;
        RECT 140.050 96.340 185.080 96.740 ;
        RECT 58.210 86.100 60.210 96.220 ;
        RECT 68.915 89.280 69.915 92.280 ;
        RECT 83.345 89.280 84.345 92.280 ;
        RECT 93.150 86.100 95.080 96.220 ;
        RECT 140.190 93.440 184.440 94.260 ;
        RECT 151.005 89.280 152.005 92.280 ;
        RECT 175.000 89.280 176.000 92.280 ;
        RECT 140.190 88.060 184.440 88.880 ;
        RECT 58.210 85.460 95.080 86.100 ;
        RECT 140.050 85.580 185.080 85.980 ;
        RECT 58.210 75.340 60.210 85.460 ;
        RECT 68.915 79.280 69.915 82.280 ;
        RECT 83.345 79.280 84.345 82.280 ;
        RECT 93.150 75.340 95.080 85.460 ;
        RECT 140.190 82.680 184.440 83.500 ;
        RECT 151.005 79.280 152.005 82.280 ;
        RECT 175.000 79.280 176.000 82.280 ;
        RECT 140.190 77.300 184.440 78.120 ;
        RECT 58.210 74.700 95.080 75.340 ;
        RECT 140.050 74.820 185.080 75.220 ;
        RECT 58.210 73.060 60.210 74.700 ;
        RECT 93.150 73.060 95.080 74.700 ;
        RECT 58.210 72.420 95.080 73.060 ;
        RECT 140.050 72.540 185.080 72.940 ;
        RECT 24.865 65.480 25.865 68.480 ;
        RECT 24.865 55.480 25.865 58.480 ;
        RECT 23.315 41.680 24.315 44.680 ;
        RECT 23.315 31.680 24.315 34.680 ;
        RECT 24.865 17.880 25.865 20.880 ;
        RECT 24.865 7.880 25.865 10.880 ;
        RECT 32.150 1.660 32.440 72.240 ;
        RECT 58.210 62.300 60.210 72.420 ;
        RECT 67.365 65.480 68.365 68.480 ;
        RECT 84.895 65.480 85.895 68.480 ;
        RECT 93.150 62.300 95.080 72.420 ;
        RECT 140.190 69.640 184.440 70.460 ;
        RECT 149.155 65.480 150.155 68.480 ;
        RECT 173.450 65.480 174.450 68.480 ;
        RECT 140.190 64.260 184.440 65.080 ;
        RECT 58.210 61.660 95.080 62.300 ;
        RECT 140.050 61.780 185.080 62.180 ;
        RECT 58.210 51.540 60.210 61.660 ;
        RECT 67.365 55.480 68.365 58.480 ;
        RECT 84.895 55.480 85.895 58.480 ;
        RECT 93.150 51.540 95.080 61.660 ;
        RECT 140.190 58.880 184.440 59.700 ;
        RECT 149.155 55.480 150.155 58.480 ;
        RECT 173.450 55.480 174.450 58.480 ;
        RECT 140.190 53.500 184.440 54.320 ;
        RECT 58.210 50.900 95.080 51.540 ;
        RECT 140.050 51.020 185.080 51.420 ;
        RECT 58.210 49.260 60.210 50.900 ;
        RECT 93.150 49.260 95.080 50.900 ;
        RECT 58.210 48.620 95.080 49.260 ;
        RECT 140.050 48.740 185.080 49.140 ;
        RECT 58.210 38.500 60.210 48.620 ;
        RECT 68.915 41.680 69.915 44.680 ;
        RECT 83.345 41.680 84.345 44.680 ;
        RECT 93.150 38.500 95.080 48.620 ;
        RECT 140.190 45.840 184.440 46.660 ;
        RECT 151.005 41.680 152.005 44.680 ;
        RECT 175.000 41.680 176.000 44.680 ;
        RECT 140.190 40.460 184.440 41.280 ;
        RECT 58.210 37.860 95.080 38.500 ;
        RECT 140.050 37.980 185.080 38.380 ;
        RECT 58.210 27.740 60.210 37.860 ;
        RECT 68.915 31.680 69.915 34.680 ;
        RECT 83.345 31.680 84.345 34.680 ;
        RECT 93.150 27.740 95.080 37.860 ;
        RECT 140.190 35.080 184.440 35.900 ;
        RECT 151.005 31.680 152.005 34.680 ;
        RECT 175.000 31.680 176.000 34.680 ;
        RECT 140.190 29.700 184.440 30.520 ;
        RECT 58.210 27.100 95.080 27.740 ;
        RECT 140.050 27.220 185.080 27.620 ;
        RECT 58.210 25.460 60.210 27.100 ;
        RECT 93.150 25.460 95.080 27.100 ;
        RECT 58.210 24.820 95.080 25.460 ;
        RECT 140.050 24.940 185.080 25.340 ;
        RECT 58.210 14.700 60.210 24.820 ;
        RECT 67.365 17.880 68.365 20.880 ;
        RECT 84.895 17.880 85.895 20.880 ;
        RECT 93.150 14.700 95.080 24.820 ;
        RECT 140.190 22.040 184.440 22.860 ;
        RECT 149.155 17.880 150.155 20.880 ;
        RECT 173.450 17.880 174.450 20.880 ;
        RECT 140.190 16.660 184.440 17.480 ;
        RECT 58.210 14.060 95.080 14.700 ;
        RECT 140.050 14.180 185.080 14.580 ;
        RECT 58.210 3.940 60.210 14.060 ;
        RECT 67.365 7.880 68.365 10.880 ;
        RECT 84.895 7.880 85.895 10.880 ;
        RECT 93.150 3.940 95.080 14.060 ;
        RECT 140.190 11.280 184.440 12.100 ;
        RECT 149.155 7.880 150.155 10.880 ;
        RECT 173.450 7.880 174.450 10.880 ;
        RECT 140.190 5.900 184.440 6.720 ;
        RECT 58.210 3.300 95.080 3.940 ;
        RECT 140.050 3.420 185.080 3.820 ;
        RECT 58.210 0.340 60.210 3.300 ;
        RECT 93.150 1.660 95.080 3.300 ;
        RECT 306.420 1.660 308.350 192.060 ;
        RECT 309.420 1.660 311.350 192.060 ;
        RECT 315.420 184.480 316.420 187.480 ;
        RECT 315.420 174.480 316.420 177.480 ;
        RECT 317.270 160.680 318.270 163.680 ;
        RECT 317.270 150.680 318.270 153.680 ;
        RECT 315.420 136.880 316.420 139.880 ;
        RECT 315.420 126.880 316.420 129.880 ;
        RECT 317.270 113.080 318.270 116.080 ;
        RECT 317.270 103.080 318.270 106.080 ;
        RECT 315.420 89.280 316.420 92.280 ;
        RECT 315.420 79.280 316.420 82.280 ;
        RECT 317.270 65.480 318.270 68.480 ;
        RECT 317.270 55.480 318.270 58.480 ;
        RECT 315.420 41.680 316.420 44.680 ;
        RECT 315.420 31.680 316.420 34.680 ;
        RECT 317.270 17.880 318.270 20.880 ;
        RECT 317.270 7.880 318.270 10.880 ;
      LAYER Metal3 ;
        RECT 23.315 182.480 24.315 185.480 ;
        RECT 68.915 182.480 69.915 185.480 ;
        RECT 83.345 182.480 84.345 185.480 ;
        RECT 151.005 182.480 152.005 185.480 ;
        RECT 23.315 176.480 24.315 179.480 ;
        RECT 68.915 176.480 69.915 179.480 ;
        RECT 83.345 176.480 84.345 179.480 ;
        RECT 151.005 176.480 152.005 179.480 ;
        RECT 24.865 158.680 25.865 161.680 ;
        RECT 67.365 158.680 68.365 161.680 ;
        RECT 84.895 158.680 85.895 161.680 ;
        RECT 149.155 158.680 150.155 161.680 ;
        RECT 24.865 152.680 25.865 155.680 ;
        RECT 67.365 152.680 68.365 155.680 ;
        RECT 84.895 152.680 85.895 155.680 ;
        RECT 149.155 152.680 150.155 155.680 ;
        RECT 1.890 134.880 2.890 137.880 ;
        RECT 19.290 134.880 20.290 137.880 ;
        RECT 23.315 134.880 24.315 137.880 ;
        RECT 68.915 134.880 69.915 137.880 ;
        RECT 83.345 134.880 84.345 137.880 ;
        RECT 151.005 134.880 152.005 137.880 ;
        RECT 1.890 128.880 2.890 131.880 ;
        RECT 19.290 128.880 20.290 131.880 ;
        RECT 23.315 128.880 24.315 131.880 ;
        RECT 68.915 128.880 69.915 131.880 ;
        RECT 83.345 128.880 84.345 131.880 ;
        RECT 151.005 128.880 152.005 131.880 ;
        RECT 4.890 111.080 5.890 114.080 ;
        RECT 16.290 111.080 17.290 114.080 ;
        RECT 24.865 111.080 25.865 114.080 ;
        RECT 67.365 111.080 68.365 114.080 ;
        RECT 84.895 111.080 85.895 114.080 ;
        RECT 149.155 111.080 150.155 114.080 ;
        RECT 4.890 105.080 5.890 108.080 ;
        RECT 16.290 105.080 17.290 108.080 ;
        RECT 24.865 105.080 25.865 108.080 ;
        RECT 67.365 105.080 68.365 108.080 ;
        RECT 84.895 105.080 85.895 108.080 ;
        RECT 149.155 105.080 150.155 108.080 ;
        RECT 23.315 87.280 24.315 90.280 ;
        RECT 68.915 87.280 69.915 90.280 ;
        RECT 83.345 87.280 84.345 90.280 ;
        RECT 151.005 87.280 152.005 90.280 ;
        RECT 23.315 81.280 24.315 84.280 ;
        RECT 68.915 81.280 69.915 84.280 ;
        RECT 83.345 81.280 84.345 84.280 ;
        RECT 151.005 81.280 152.005 84.280 ;
        RECT 24.865 63.480 25.865 66.480 ;
        RECT 67.365 63.480 68.365 66.480 ;
        RECT 84.895 63.480 85.895 66.480 ;
        RECT 149.155 63.480 150.155 66.480 ;
        RECT 24.865 57.480 25.865 60.480 ;
        RECT 67.365 57.480 68.365 60.480 ;
        RECT 84.895 57.480 85.895 60.480 ;
        RECT 149.155 57.480 150.155 60.480 ;
        RECT 23.315 39.680 24.315 42.680 ;
        RECT 68.915 39.680 69.915 42.680 ;
        RECT 83.345 39.680 84.345 42.680 ;
        RECT 151.005 39.680 152.005 42.680 ;
        RECT 23.315 33.680 24.315 36.680 ;
        RECT 68.915 33.680 69.915 36.680 ;
        RECT 83.345 33.680 84.345 36.680 ;
        RECT 151.005 33.680 152.005 36.680 ;
        RECT 24.865 15.880 25.865 18.880 ;
        RECT 67.365 15.880 68.365 18.880 ;
        RECT 84.895 15.880 85.895 18.880 ;
        RECT 149.155 15.880 150.155 18.880 ;
        RECT 24.865 9.880 25.865 12.880 ;
        RECT 67.365 9.880 68.365 12.880 ;
        RECT 84.895 9.880 85.895 12.880 ;
        RECT 149.155 9.880 150.155 12.880 ;
        RECT 157.110 0.340 159.110 192.740 ;
        RECT 160.170 0.340 162.170 192.740 ;
        RECT 163.230 0.340 165.230 192.740 ;
        RECT 166.290 0.340 168.290 192.740 ;
        RECT 175.000 182.480 176.000 185.480 ;
        RECT 315.420 182.480 316.420 185.480 ;
        RECT 175.000 176.480 176.000 179.480 ;
        RECT 315.420 176.480 316.420 179.480 ;
        RECT 173.450 158.680 174.450 161.680 ;
        RECT 317.270 158.680 318.270 161.680 ;
        RECT 173.450 152.680 174.450 155.680 ;
        RECT 317.270 152.680 318.270 155.680 ;
        RECT 175.000 134.880 176.000 137.880 ;
        RECT 315.420 134.880 316.420 137.880 ;
        RECT 175.000 128.880 176.000 131.880 ;
        RECT 315.420 128.880 316.420 131.880 ;
        RECT 173.450 111.080 174.450 114.080 ;
        RECT 317.270 111.080 318.270 114.080 ;
        RECT 173.450 105.080 174.450 108.080 ;
        RECT 317.270 105.080 318.270 108.080 ;
        RECT 175.000 87.280 176.000 90.280 ;
        RECT 315.420 87.280 316.420 90.280 ;
        RECT 175.000 81.280 176.000 84.280 ;
        RECT 315.420 81.280 316.420 84.280 ;
        RECT 173.450 63.480 174.450 66.480 ;
        RECT 317.270 63.480 318.270 66.480 ;
        RECT 173.450 57.480 174.450 60.480 ;
        RECT 317.270 57.480 318.270 60.480 ;
        RECT 175.000 39.680 176.000 42.680 ;
        RECT 315.420 39.680 316.420 42.680 ;
        RECT 175.000 33.680 176.000 36.680 ;
        RECT 315.420 33.680 316.420 36.680 ;
        RECT 173.450 15.880 174.450 18.880 ;
        RECT 317.270 15.880 318.270 18.880 ;
        RECT 173.450 9.880 174.450 12.880 ;
        RECT 317.270 9.880 318.270 12.880 ;
      LAYER Metal4 ;
        RECT 23.315 177.980 24.315 183.980 ;
        RECT 68.915 177.980 69.915 183.980 ;
        RECT 83.345 177.980 84.345 183.980 ;
        RECT 151.005 177.980 152.005 183.980 ;
        RECT 175.000 177.980 176.000 183.980 ;
        RECT 315.420 177.980 316.420 183.980 ;
        RECT 24.865 154.180 25.865 160.180 ;
        RECT 67.365 154.180 68.365 160.180 ;
        RECT 84.895 154.180 85.895 160.180 ;
        RECT 149.155 154.180 150.155 160.180 ;
        RECT 173.450 154.180 174.450 160.180 ;
        RECT 317.270 154.180 318.270 160.180 ;
        RECT 1.890 130.380 2.890 136.380 ;
        RECT 19.290 130.380 20.290 136.380 ;
        RECT 23.315 130.380 24.315 136.380 ;
        RECT 68.915 130.380 69.915 136.380 ;
        RECT 83.345 130.380 84.345 136.380 ;
        RECT 151.005 130.380 152.005 136.380 ;
        RECT 175.000 130.380 176.000 136.380 ;
        RECT 315.420 130.380 316.420 136.380 ;
        RECT 4.890 106.580 5.890 112.580 ;
        RECT 16.290 106.580 17.290 112.580 ;
        RECT 24.865 106.580 25.865 112.580 ;
        RECT 67.365 106.580 68.365 112.580 ;
        RECT 84.895 106.580 85.895 112.580 ;
        RECT 149.155 106.580 150.155 112.580 ;
        RECT 173.450 106.580 174.450 112.580 ;
        RECT 317.270 106.580 318.270 112.580 ;
        RECT 23.315 82.780 24.315 88.780 ;
        RECT 68.915 82.780 69.915 88.780 ;
        RECT 83.345 82.780 84.345 88.780 ;
        RECT 151.005 82.780 152.005 88.780 ;
        RECT 175.000 82.780 176.000 88.780 ;
        RECT 315.420 82.780 316.420 88.780 ;
        RECT 24.865 58.980 25.865 64.980 ;
        RECT 67.365 58.980 68.365 64.980 ;
        RECT 84.895 58.980 85.895 64.980 ;
        RECT 149.155 58.980 150.155 64.980 ;
        RECT 173.450 58.980 174.450 64.980 ;
        RECT 317.270 58.980 318.270 64.980 ;
        RECT 23.315 35.180 24.315 41.180 ;
        RECT 68.915 35.180 69.915 41.180 ;
        RECT 83.345 35.180 84.345 41.180 ;
        RECT 151.005 35.180 152.005 41.180 ;
        RECT 175.000 35.180 176.000 41.180 ;
        RECT 315.420 35.180 316.420 41.180 ;
        RECT 24.865 11.380 25.865 17.380 ;
        RECT 67.365 11.380 68.365 17.380 ;
        RECT 84.895 11.380 85.895 17.380 ;
        RECT 149.155 11.380 150.155 17.380 ;
        RECT 173.450 11.380 174.450 17.380 ;
        RECT 317.270 11.380 318.270 17.380 ;
      LAYER Metal5 ;
        RECT 0.000 179.980 320.160 181.980 ;
        RECT 0.000 156.180 320.160 158.180 ;
        RECT 0.000 132.380 320.160 134.380 ;
        RECT 0.000 108.580 320.160 110.580 ;
        RECT 0.000 84.780 320.160 86.780 ;
        RECT 0.000 60.980 320.160 62.980 ;
        RECT 0.000 37.180 320.160 39.180 ;
        RECT 0.000 13.380 320.160 15.380 ;
  END
END line_driver
END LIBRARY

